# Keil uVision project led.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\armv7cortex-m4\CCS_workspace\Project1\Mcal\GPIO\Inc;D:\armv7cortex-m4\CCS_workspace\Project1\Mcal\Interrupt\inc;D:\armv7cortex-m4\CCS_workspace\Project1\Mcal\Systick\Inc;D:\armv7cortex-m4\CCS_workspace\Project1\Mcal\Ral;D:\armv7cortex-m4\CCS_workspace\Project1\Config;D:\armv7cortex-m4\CCS_workspace\Project1\common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    D:/armv7cortex-m4/CCS_workspace/Project1/Mcal/GPIO/: DIO.c GPIO.c
    D:/armv7cortex-m4/CCS_workspace/Project1/Mcal/Interrupt/: IntCtrl.c IntTypes.c
    D:/armv7cortex-m4/CCS_workspace/Project1/Mcal/Systick/: Systick.c
  group Config
    D:/armv7cortex-m4/CCS_workspace/Project1/Config/: GPIO_conf.c IntCtrl_Conf.c Systick_Config.c
  group App
    D:/armv7cortex-m4/CCS_workspace/Project1/App/: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
